options:
  parameters:
    author: Yachen Mao
    generate_options: qt_gui
    id: ook
    output_language: python
    title: ook
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '83'
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '0'
    reference: '1'
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0.05'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-725000'
    sample_rate: samp_rate
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.1'
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1 / 16
    lengthtagname: packet_len
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '110100100011'
    tagname: syncword
    threshold: '0'
    type: byte
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: CRC16_CCIT_ZERO
    final_xor: '0x0'
    initial_value: '0x0'
    input_reflected: 'False'
    num_bits: '16'
    poly: '0x1021'
    result_reflected: 'False'
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '1'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '8'
    ted_gain: '0.0147625'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):
          """FM0 Decode"""

          def __init__(self):
              gr.decim_block.__init__(
                  self,
                  name="FM0 Decode",
                  in_sig=[np.byte],
                  out_sig=[np.byte],
                  decim=2,
              )

          def work(self, input_items, output_items):
              x1 = input_items[0][0::2]
              x2 = input_items[0][1::2]
              output_items[0][:] = np.byte(np.logical_not(np.logical_xor(x1, x2)))
              return len(output_items[0])
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1.0]*83'
    type: fff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 18e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 18e3
    win: window.WIN_HANN
  states: {}
- name: mmse_resampler_xx_0_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: '10.5'
    type: float
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 915e6
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 915e6
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: satellites_fixedlen_tagger_0
  id: satellites_fixedlen_tagger
  parameters:
    packet_len: '544'
    packetlen_tag: packet_len
    stream_type: byte
    syncword_tag: syncword
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '915000000'
    gain0: '0'
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '915000000'
    dc_offs_enb0: disabled
    gain0: '20'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mag
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: sync
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: threshold
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: packet_align
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mag
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: sync
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: threshold
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: packet_align
  states: {}

connections:
- [analog_agc2_xx_0_0, '0', blocks_freqshift_cc_0, '0']
- [analog_const_source_x_0, '0', blocks_max_xx_0, '0']
- [analog_const_source_x_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_argmax_xx_0, '0', blocks_null_sink_0, '0']
- [blocks_argmax_xx_0, '1', blocks_short_to_float_0, '0']
- [blocks_complex_to_mag_0, '0', virtual_sink_0, '0']
- [blocks_float_to_uchar_0, '0', virtual_sink_2, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0, '0']
- [blocks_max_xx_0, '0', blocks_argmax_xx_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_rms_xx_0, '0', blocks_max_xx_0, '1']
- [blocks_short_to_float_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_tagged_stream_align_0, '0', epy_block_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', satellites_fixedlen_tagger_0, '0']
- [digital_crc_check_0, ok, blocks_message_debug_0, print]
- [digital_crc_check_0, ok, network_socket_pdu_0, pdus]
- [digital_symbol_sync_xx_1, '0', qtgui_time_sink_x_2, '0']
- [digital_symbol_sync_xx_1, '0', virtual_sink_1, '0']
- [digital_symbol_sync_xx_1, '1', qtgui_time_sink_x_2, '1']
- [epy_block_0, '0', virtual_sink_3, '0']
- [fir_filter_xxx_0, '0', mmse_resampler_xx_0_0_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [mmse_resampler_xx_0_0_0, '0', digital_symbol_sync_xx_1, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc_check_0, in]
- [satellites_fixedlen_tagger_0, '0', blocks_tagged_stream_align_0, '0']
- [uhd_usrp_source_0, '0', analog_agc2_xx_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', fir_filter_xxx_0, '0']
- [virtual_source_1, '0', blocks_argmax_xx_0, '1']
- [virtual_source_1, '0', blocks_rms_xx_0, '0']
- [virtual_source_2, '0', digital_correlate_access_code_tag_xx_0, '0']
- [virtual_source_3, '0', blocks_repack_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
